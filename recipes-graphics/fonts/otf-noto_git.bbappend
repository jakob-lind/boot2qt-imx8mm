SRC_URI = "git://github.com/googlefonts/noto-cjk.git;branch=main"
SRCREV = "40d9f5b179a59a06b98373c76bdc3e2119e4e6b2"
