FILESEXTRAPATHS_prepend := "${THISDIR}/compulab/imx8mm:"

include compulab/imx8mm.inc

COMPATIBLE_MACHINE = "raysafe-imx8mm"
